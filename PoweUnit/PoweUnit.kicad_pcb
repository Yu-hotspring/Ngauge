# Repository Yu-hotspring/Ngauge

## KiCad design PoweUnit/PoweUnit.kicad_pcb

Parts:
C1: 0.01u; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2: 1u; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3: 0.1u; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1: LED; LED_D5.0mm
D2: short; LED_D5.0mm
F1: Polyfuse; Fuse_Bourns_MF-RG1000
J1: Jack-DC; MJ-179PH
J2: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Horizontal
J3: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Horizontal
J4: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
Q1: Q_PMOS_GDS; TO-251-3_Vertical
R1, R2: 5.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 10k; SL4515NB103L15CM
SW1: SW_SPST; CW-SB11KKFF
SW2: SW_Slide_DPDT; SS22F06G5G
U1: NE555D; SOIC-8_3.9x4.9mm_P1.27mm
U2: NJM2746M; SOIC127P680X200-8N

Connections:
+12V: D1.2 (A), D2.2 (A), F1.1, J1.1, J2.1, J3.1
/Feeder+: J4.1, SW2.3 (C), SW2.6 (C)
/Feeder-: J4.2, SW2.1 (A), SW2.4 (A)
/PWM_OUT: Q1.2 (D), R6.1, SW2.2 (B)
GND: C1.2, C2.2, C3.2, J1.2, J2.2, J3.2, R1.2, R6.2, RV1.3, SW2.5 (B), U1.1 (GND), U2.4 (V-), U2.5 (+), U2.6 (-)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.2
unnamed: Q1.1 (G), R5.2, U2.1
unnamed: F1.2, R2.1, SW1.1 (A)
unnamed: R3.2, R4.1, U1.7 (DISCH)
unnamed: C1.1, R4.2, U1.2 (TRIG), U1.6 (THRES), U2.2 (-)
unnamed: RV1.2, U2.3 (+)
VCC: C2.1, C3.1, Q1.3 (S), R3.1, R5.1, RV1.1, SW1.2 (B), U1.4 (~RST), U1.8 (VCC), U2.8 (V+)

Notes on the sheet:
ACアダプタ
フィーダ出力
DCジャック
PMOS
PWM生成
注意 0.5A MAX
ロッカースイッチ
並列接続用コネクタ
電源12V 20kHzPWM,0~100% 定電流源モードあり 方向切替SW
DPDT

Board: 2 copper layers, 70.0 x 70.0 mm, 22 parts (0 on the bottom side), 13 nets.

## Commit log

2026-04-29 継電連動装置の諸々
2026-05-28 PU回路図書いた
2026-05-29 パワーパック完成
2026-05-31 連動操作盤回路つくる
2026-06-02 リレー論理回路で悩み中
